# Keil uVision project GPIO.uvproj, settings and files
target GPIO (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: GPIO +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\..\GPIO_test;..\lib\CMSIS\Include;..\lib\CMSIS\Device\ST\STM32F4xx\Include;..\lib\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f40xx.s
  group main
    ../source/: main.c
    ../lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lib
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
